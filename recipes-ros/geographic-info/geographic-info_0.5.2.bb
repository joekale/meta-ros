DESCRIPTION = "Python and C++ interfaces for manipulating geodetic coordinates."
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "geodesy geographic-msgs"

require geographic-info.inc
