DESCRIPTION = "Python and C++ interfaces for manipulating geodetic coordinates."
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "angles geographic-msgs geometry-msgs sensor-msgs tf unique-id uuid-msgs catkin"

require geographic-info.inc
