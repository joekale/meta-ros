DESCRIPTION = "swri_math_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "catkin boost yaml-cpp"

require marti-common.inc
