DESCRIPTION = "The swri_transform_util package contains utility functions and classes for transforming between coordinate frames."
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "cv-bridge geos cmake-modules libeigen roscpp tf"

require marti-common.inc
