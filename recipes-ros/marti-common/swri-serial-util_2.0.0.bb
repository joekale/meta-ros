DESCRIPTION = "swri_serial_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "boost"

require marti-common.inc
