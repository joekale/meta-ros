DESCRIPTION = "The swri_transform_util package contains utility functions and classes for transforming between coordinate frames."
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "camera-calibration-parsers cv-bridge geometry-msgs image-geometry image-transport message-filters nav-msgs nodelet roscpp rospy \
	std-msgs swri-geometry-util swri-math-util swri-nodelet swri-opencv-util swri-roscpp tf libeigen"

require marti-common.inc
