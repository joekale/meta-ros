DESCRIPTION = "swri_opencv_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "cv-bridge swri-math-util"

require marti-common.inc
