DESCRIPTION = "swri_math_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "roscpp swri-math-util"

PREFERRED_RPROVIDER = "packagegroup-marti-common"

require marti-common.inc
