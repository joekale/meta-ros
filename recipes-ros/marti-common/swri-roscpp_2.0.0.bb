DESCRIPTION = "swri_opencv_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "nav-msgs roscpp std-msgs std-srvs diagnostic-updater"

require marti-common.inc
