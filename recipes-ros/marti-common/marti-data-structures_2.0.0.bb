DESCRIPTION = "marti_data_structures"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "roscpp"

require marti-common.inc
