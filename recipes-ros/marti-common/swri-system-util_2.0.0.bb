DESCRIPTION = "swri_system_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "roscpp"

require marti-common.inc
