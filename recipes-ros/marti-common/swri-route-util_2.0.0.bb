DESCRIPTION = "swri_opencv_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "marti-common-msgs marti-nav-msgs roscpp swri-transform-util swri-math-util swri-geometry-util visualization-msgs"

require marti-common.inc
