DESCRIPTION = "The swri_transform_util package contains utility functions and classes for transforming between coordinate frames."
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "boost cv-bridge diagnostic-msgs dynamic-reconfigure geographic-msgs geometry-msgs gps-common nodelet topic-tools \
		swri-math-util swri-roscpp swri-yaml-util proj tf"

require marti-common.inc
