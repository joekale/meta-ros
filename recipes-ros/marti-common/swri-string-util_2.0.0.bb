DESCRIPTION = "swri_string_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = ""

require marti-common.inc
