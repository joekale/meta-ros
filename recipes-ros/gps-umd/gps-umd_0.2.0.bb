DESCRIPTION = "swri_math_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "gps-common gps-client"

require gps-umd.inc
