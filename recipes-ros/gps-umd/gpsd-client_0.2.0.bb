DESCRIPTION = "swri_math_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "gps-common roscpp sensor-msgs"

require gps-umd.inc
