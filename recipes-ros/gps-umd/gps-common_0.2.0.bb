DESCRIPTION = "swri_math_util"
SECTION = "devel"
LICENSE = "CLOSED"

DEPENDS = "message-filters nav-msgs roscpp sensor-msgs std-msgs rospy"

require gps-umd.inc
